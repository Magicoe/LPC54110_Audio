# Keil uVision project project_gcc.uvprojx, settings and files
target rtthread-lpc5410x (ARM-GNU)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project_gcc
  group Applications
    applications/: application.c board.c demo_thread.c startup.c
    ./applications/: mp3.c netbuffer.c wm8904_test.c wma.c
    ./wav/: wav.c
    ./flac/: ext_flac.c
    ./ogg/: ivorbisfile_example.c
    ./ape/: demac.c
  group Drivers
    drivers/: drv_led.c drv_uart.c
    ./drivers/: drv_spi.c drv_i2c.c drv_msd_spi.c drv_i2s_wm8904.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group CMSIS
    Libraries/Device/startup/: sysinit.c keil_startup_lpc5410x.s
  group Libraries
    Libraries/lpc_chip/chip_common/: fpu_init.c iap.c ring_buffer.c rtc_ut.c
    ./Libraries/lpc_chip/chip_5410x/: adc_5411x.c chip_5411x.c clock_5411x.c crp.c dma_5411x.c dma_service_5411x.c dmic_5411x.c flexcomm_5411x.c i2cm_5411x.c i2cs_5411x.c mtb.c pll_5411x.c sct_5411x.c sct_pwm_5411x.c spi_common_5411x.c spim_5411x.c spis_5411x.c stopwatch_5411x.c syscon_5411x.c sysinit.c sysinit_5411x.c timer_5411x.c uart_5411x.c keil_lib_power.lib i2s_5411x.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group FileSystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group mp3_decode
    ./mp3/: mp3dec.c mp3tabs.c
    ./mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
    ./mp3/real/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group flac_decode
    ./flac/: bitstreamf.c decoder.c tables.c
  group wma_decode
    ./libwma/: mdct2.c wmabitstream.c wmadeci.c wmafixed.c mdct_arm.S wma_arm.S
  group ogg_decode
    ./ogg/: bitwise.c codebook.c dsp.c floor_lookup.c floor0.c floor1.c framing.c info.c mapping0.c mdct.c ogg_misc.c res012.c vorbisfile.c
  group ape_decode
    ./ape/: predictor-arm.S crc.c decoder.c entropy.c filter.c filter_16_11.c filter_32_10.c filter_64_11.c filter_256_13.c filter_1280_15.c parser.c predictor.c
