# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc5410x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54113J256UK49:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc5410x +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: CORE_M4 CHIP_LPC5411X
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\lpc_chip\chip_5410x;Libraries\lpc_chip\chip_5410x\config;Libraries\lpc_chip\chip_common;applications;drivers;..\..\components\dfs;..\..\components\dfs\include;..\..\components\drivers\spi;..\..\components\drivers\i2c;..\..\components\drivers\include;..\..\components\drivers\include\drivers;.\mp3\pub;.\flac;.\libwma3;.\ogg;.\ape
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\build\rtthread-lpc5410x.sct
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c board.c demo_thread.c startup.c
    ./applications/: mp3.c netbuffer.c wm8904_test.c wma.c
    ./wav/: wav.c
    ./flac/: ext_flac.c
    ./ogg/: ivorbisfile_example.c
    ./ape/: demac.c
  group Drivers
    drivers/: drv_led.c drv_uart.c
    ./drivers/: drv_spi.c drv_i2c.c drv_msd_spi.c drv_i2s_wm8904.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group CMSIS
    Libraries/Device/startup/: sysinit.c keil_startup_lpc5410x.s
  group Libraries
    Libraries/lpc_chip/chip_common/: fpu_init.c iap.c ring_buffer.c rtc_ut.c
    ./Libraries/lpc_chip/chip_5410x/: adc_5411x.c chip_5411x.c clock_5411x.c crp.c dma_5411x.c dma_service_5411x.c dmic_5411x.c flexcomm_5411x.c i2cm_5411x.c i2cs_5411x.c mtb.c pll_5411x.c sct_5411x.c sct_pwm_5411x.c spi_common_5411x.c spim_5411x.c spis_5411x.c stopwatch_5411x.c syscon_5411x.c sysinit.c sysinit_5411x.c timer_5411x.c uart_5411x.c keil_lib_power.lib i2s_5411x.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group FileSystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group mp3_decode
    ./mp3/: mp3dec.c mp3tabs.c
    ./mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
    ./mp3/real/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group flac_decode
    ./flac/: bitstreamf.c decoder.c tables.c
  group wma_decode
    ./libwma/: mdct2.c wmabitstream.c wmadeci.c wmafixed.c mdct_arm.S wma_arm.S
  group ogg_decode
    ./ogg/: bitwise.c codebook.c dsp.c floor_lookup.c floor0.c floor1.c framing.c info.c mapping0.c mdct.c ogg_misc.c res012.c vorbisfile.c
  group ape_decode
    ./ape/: predictor-arm.S crc.c decoder.c entropy.c filter.c filter_16_11.c filter_32_10.c filter_64_11.c filter_256_13.c filter_1280_15.c parser.c predictor.c
  group media_lib
    ./media_lib/: wmadec_lib.lib
